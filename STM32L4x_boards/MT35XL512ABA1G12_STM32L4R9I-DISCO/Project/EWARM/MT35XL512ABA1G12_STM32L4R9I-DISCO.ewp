# IAR project MT35XL512ABA1G12_STM32L4R9I-DISCO.ewp, settings and files
configuration MT35XL512ABA1G12_STM32L4R9I-DISCO (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: STM32L4R9xx
  ICCARM.CCIncludePath2: ..\..\Includes\Library; ..\..\Includes\Loader; ..\..\Includes\CMSIS
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MT35XL512ABA1G12_STM32L4R9I-DISCO.hex
  ILINK.IlinkOutputFile: MT35XL512ABA1G12_STM32L4R9I-DISCO.stldr
  ILINK.IlinkIcfFile: Target.icf
  ILINK.IlinkProgramEntryLabel: Init
  group Doc
    ../../: readme.txt
  group Library
    ../../Sources/Library/: stm32l4r9i_discovery_ospi_nor.c stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_gpio.c stm32l4xx_hal_ospi.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c system_stm32l4xx.c
  group Loader
    ../../Sources/Loader/: Dev_Inf.c Loader_Src.c
