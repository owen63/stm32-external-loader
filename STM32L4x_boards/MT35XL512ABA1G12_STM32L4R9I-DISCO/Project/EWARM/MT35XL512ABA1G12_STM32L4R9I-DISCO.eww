<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\MT35XL512ABA1G12_STM32L4R9I-DISCO.ewp</path>
    </project>
    <batchBuild />
</workspace>
